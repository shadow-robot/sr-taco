Commit message: Fully working environment with a suitcase that can be opened

File: sr_taco_launch/other/simple_box.urdf (robot description, URDF)
Before this commit: robot simple_box, 1 links, 0 joints
Links:
- link my_box: geometry collision box size=0.1 0.1 0.3; visual box size=0.03 0.03 0.3
